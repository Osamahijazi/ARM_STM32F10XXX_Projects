# Keil uVision project App2.uvprojx, settings and files
target stm32f103 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./files/: CAN .c CAN_cfg.c CanIf.c CanIf_cfg.c GPIO.c main.c RCC.c STK_Program.c Alarm.c UltraSensor.c
  group inc
    ./files/: CAN_cfg.h CAN_Interface.h CAN_Private.h CanIf_cfg.h CanIf_Interface.h CanIf_Private.h Compiler.h GPIO_cfg.h GPIO_interface.h GPIO_private.h Platform_Types.h RCC_cfg.h RCC_interface.h RCC_private.h Std_Types.h STK_Config.h STK_Interface.h STK_Private.h BIT_MATH.h UltraSensor_Interface.h UltraSensor_Cfg.h UltraSensor_Private.h Alarm_cfg.h Alarm_Interface.h Alarm_Private.h
  group Rte
    ./RTE-GIT/: Rte.c Rte_Type.h Rte_Buzzer.h Rte_DistanceSensor.h
  group SWCs
    ./RTE-GIT/: DistanceSensor.c Buzzer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
