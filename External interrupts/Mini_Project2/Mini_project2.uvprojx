# Keil uVision project Mini_project2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mini_project2 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group owner Lib
    ./: EXTI_Program.c EXTI_Interface.h EXTI_Private.h GPIO_interface.h GPIO_private.h GPIO_program.c MATH_BIT.h NVIC_Interface.h NVIC_Private.h NVIC_Program.c RCC_interface.h RCC_private.h RCC_program.c STD_TYPES.h SYSTIMER_Private.h SYSTIMER_Program.c SYSTIMER_Interface.h AFIO_Interface.h AFIO_Private.h AFIO_Program.c LED_DISPLAY.c LED_DISPLAY.h
  group user_config
    ./: EXTI_Config.h AFIO_Config.h SYSTIMER_Config.h RCC_config.h NVIC_Config.h GPIO_config.h main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
