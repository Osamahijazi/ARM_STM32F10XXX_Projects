# Keil uVision project OS_SCHEDULER.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OS_SCHEDULER +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: AFIO_Config.h AFIO_Interface.h AFIO_Private.h AFIO_Program.c EXTI_Config.h EXTI_Interface.h EXTI_Private.h EXTI_Program.c GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c LEDMRX_Config.h LEDMRX_Interface.h LEDMRX_Private.h LEDMRX_Program.c MATH_BIT.h NVIC_Config.h NVIC_Interface.h NVIC_Private.h NVIC_Program.c OS_Config.h OS_Interface.h OS_Private.h OS_Progam.c RCC_config.h RCC_interface.h RCC_private.h RCC_program.c STD_TYPES.h SYSTIMER_Config.h SYSTIMER_Interface.h SYSTIMER_Private.h SYSTIMER_Program.c main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
